# Keil uVision project RFID.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RFID_1 +hex
  c flags: Optim=1
  c include: .\Includes
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group App
    ./App/: Startup.s main.c
  group Drivers
    ./Drivers/: kpm.c lcd.c rtc.c timer.c uart0.c spi.c spi_eeprom.c delays.c led.c buzzer.c exti_switch.c
  group Test
    ./: kpm_test.c uart_test_main.c spi_eeprom_test.c timer_test.c rtc_test.c
  group Service
    ./Service/: init.c wait.c valid.c invalid.c dashboard.c authenticate.c pan.c atm.c vote.c dl.c
  group Includes
    ./Includes/: buzzer.h defines.h delays.h exti_switch.h kpm.h lcd.h lcd_defines.h led.h rtc.h service.h spi.h spi_defines.h spi_eeprom.h timer.h types.h uart0.h
